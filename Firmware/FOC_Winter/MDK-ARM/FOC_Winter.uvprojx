# Keil uVision project FOC_Winter.uvprojx, settings and files
target FOC_Winter (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC_Winter +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__TARGET_FPU_VFP,__CC_ARM,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../DSP_Lib/Include;../Hardware/User/AS5600;../Hardware/User/delay;../Hardware/User/LCD_SPI;../Hardware/User/Usrt;../Hardware/User/GUI;..\Simple FOC\_ReadADC;..\Simple FOC\Base_Motor_Control;..\Simple FOC\CurrentSense;..\Simple FOC\FOC_Define;..\Simple FOC\FOC_Motor;..\Simple FOC\InlineCurrentSense;..\Simple FOC\Low_pass_filtering;..\Simple FOC\PID_Motor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
  group Hardware
    ../Hardware/User/AS5600/: AS5600.c
    ../Hardware/User/delay/: delay_JR.c
    ../Hardware/User/LCD_SPI/: lcd.c lcd_init.c
    ../Hardware/User/Usrt/: Usrt.c
    ../Hardware/User/GUI/: GUI.c
  group Simple foc
    ../Simple FOC/_ReadADC/: Inline_ADC.c
    ../Simple FOC/Base_Motor_Control/: Base_Motor_Control.c
    ../Simple FOC/CurrentSense/: CurrentSense.c
    ../Simple FOC/FOC_Define/: FOC_Define.c
    ../Simple FOC/FOC_Motor/: FOC_Motor.c
    ../Simple FOC/InlineCurrentSense/: InlineCurrentSense.c
    ../Simple FOC/Low_pass_filtering/: Low_pass_filtering.c
    ../Simple FOC/PID_Motor/: PID_Motor.c
software components: CMSIS:CORE 4.3.0
